#include "SineTable.h"

/*
 * Q15 正弦查找表（固定点 int16）。
 * 覆盖 [0, pi/2] 共 257 个点（含两端），步长 pi/512 ≈ 0.00614 rad。
 * 表中值 = round(sin(angle) * 32767)。
 * 使用时配合线性插值，精度优于 float 查表但 ROM 仅 514 字节。
 */
const signed short sinetable_q15[TABLE_Q15_SIZE] = {
      0,   201,   402,   603,   804,  1005,  1206,  1407,
   1608,  1809,  2009,  2210,  2410,  2611,  2811,  3012,
   3212,  3412,  3612,  3811,  4011,  4210,  4410,  4609,
   4808,  5007,  5205,  5404,  5602,  5800,  5998,  6195,
   6393,  6590,  6786,  6983,  7179,  7375,  7571,  7767,
   7962,  8157,  8351,  8545,  8739,  8933,  9126,  9319,
   9512,  9704,  9896, 10087, 10278, 10469, 10659, 10849,
  11039, 11228, 11417, 11605, 11793, 11980, 12167, 12353,
  12539, 12725, 12910, 13094, 13279, 13462, 13645, 13828,
  14010, 14191, 14372, 14553, 14732, 14912, 15090, 15269,
  15446, 15623, 15800, 15976, 16151, 16325, 16499, 16673,
  16846, 17018, 17189, 17360, 17530, 17700, 17869, 18037,
  18204, 18371, 18537, 18703, 18868, 19032, 19195, 19357,
  19519, 19680, 19841, 20000, 20159, 20317, 20475, 20631,
  20787, 20942, 21096, 21250, 21403, 21554, 21705, 21856,
  22005, 22154, 22301, 22448, 22594, 22739, 22884, 23027,
  23170, 23311, 23452, 23592, 23731, 23870, 24007, 24143,
  24279, 24413, 24547, 24680, 24811, 24942, 25072, 25201,
  25329, 25456, 25582, 25708, 25832, 25955, 26077, 26198,
  26319, 26438, 26556, 26674, 26790, 26905, 27019, 27133,
  27245, 27356, 27466, 27575, 27683, 27790, 27896, 28001,
  28105, 28208, 28310, 28411, 28510, 28609, 28706, 28803,
  28898, 28992, 29085, 29177, 29268, 29358, 29447, 29534,
  29621, 29706, 29791, 29874, 29956, 30037, 30117, 30195,
  30273, 30349, 30424, 30498, 30571, 30643, 30714, 30783,
  30852, 30919, 30985, 31050, 31113, 31176, 31237, 31297,
  31356, 31414, 31470, 31526, 31580, 31633, 31685, 31736,
  31785, 31833, 31880, 31926, 31971, 32014, 32057, 32098,
  32137, 32176, 32213, 32250, 32285, 32318, 32351, 32382,
  32412, 32441, 32469, 32495, 32521, 32545, 32567, 32589,
  32609, 32628, 32646, 32663, 32678, 32692, 32705, 32717,
  32728, 32737, 32745, 32752, 32757, 32761, 32765, 32766,
  32767,
};

/*
 * 从 Q15 表中线性插值计算 sin(θ)，θ ∈ [0, π/2]。
 * scale: 全量程 0..TABLE_Q15_SIZE-1 映射到 0..π/2。
 */
static float q15_sin_lerp(float x)
{
    // x in [0, pi/2]
    float pos = x * (TABLE_Q15_SIZE - 1) / (float)1.5707963268f; // pos in [0, 256]
    int idx = (int)pos;
    float frac = pos - (float)idx;
    if (idx >= TABLE_Q15_SIZE - 1)
    {
        idx = TABLE_Q15_SIZE - 2;
        frac = 1.0f;
    }
    float v = (float)sinetable_q15[idx] * (1.0f - frac) + (float)sinetable_q15[idx + 1] * frac;
    return v / SIN_TABLE_SCALE;
}

float lookup_sin(float x)
{
    // 归一化到 [0, 2π)
    while (x >= 6.283185307f) x -= 6.283185307f;
    while (x < 0.0f) x += 6.283185307f;

    // 象限折叠到 [0, π/2]
    if (x <= 1.5707963268f)
    {
        // Q0: [0, π/2]  sin 为正
        return q15_sin_lerp(x);
    }
    else if (x <= 3.1415926535f)
    {
        // Q1: [π/2, π]  sin = sin(π - x)
        return q15_sin_lerp(3.1415926535f - x);
    }
    else if (x <= 4.7123889803f)
    {
        // Q2: [π, 3π/2]  sin = -sin(x - π)
        return -q15_sin_lerp(x - 3.1415926535f);
    }
    else
    {
        // Q3: [3π/2, 2π]  sin = -sin(2π - x)
        return -q15_sin_lerp(6.283185307f - x);
    }
}

float lookup_cos(float x)
{
    // cos(x) = sin(π/2 - |x|)
    // 先取绝对值再查 sin，利用 cos 的偶函数性质避免负角度绕圈
    if (x < 0.0f) x = -x;
    return lookup_sin(1.5707963268f - x);
}

float lookup_tan(float x)
{
    return lookup_sin(x) / lookup_cos(x);
}

float lookup_cot(float x)
{
    return lookup_cos(x) / lookup_sin(x);
}

// ----- atan2 保持多项式近似（无查找表）-----
float lookup_atan2(float y, float x)
{
    const float ATAN_K = 0.273f;
    float pi = 3.1415926535f;
    float HALF_PI = 1.5707963268f;

    if (x == 0.0f && y == 0.0f)
    {
        return 0.0f;
    }

    if (x == 0.0f)
    {
        return (y > 0.0f) ? HALF_PI : -HALF_PI;
    }

    {
        float ay = (y >= 0.0f) ? y : -y;
        float ax = (x >= 0.0f) ? x : -x;
        float z;
        float a;

        if (ay <= ax)
        {
            z = ay / ax;
            a = z * (0.78539816325f + ATAN_K * (1.0f - z));
        }
        else
        {
            z = ax / ay;
            a = HALF_PI - z * (0.78539816325f + ATAN_K * (1.0f - z));
        }

        if (x > 0.0f)
        {
            return (y >= 0.0f) ? a : -a;
        }
        else
        {
            return (y >= 0.0f) ? (pi - a) : (a - pi);
        }
    }
}
